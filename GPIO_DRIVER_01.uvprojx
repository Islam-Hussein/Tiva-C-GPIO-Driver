# Keil uVision project GPIO_DRIVER_01.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_DRIVER_01
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c STD.h PORT.h PORT.c PORT_Cfg.h PORT_Lcfg.c mcu_hw.h
    C:/Users/islam/Documents/Atmel Studio/7.0/RTOS_ATMEGGA32/RTOS_ATMEGGA32/: BIT_MATH.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
